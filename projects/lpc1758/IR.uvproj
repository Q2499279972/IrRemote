# Keil uVision project IR.uvproj, settings and files
target LPC175x (ARM-ADS)
  device: LPC1758 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: IR +hex
  c flags: Optim=1
  c include: .\common\inc;..\..\IR
  asm include: ..\..\common\inc;.\ir
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Files
    ./common/src/: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: demo.cpp
    ../../IR/: ir_NEC.cpp IRremote.cpp
